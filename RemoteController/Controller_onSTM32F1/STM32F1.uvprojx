# Keil uVision project STM32F1.uvprojx, settings and files
target STM32F1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F1
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c misc: --diag_suppress=188 --diag_suppress=111 --diag_suppress=546 --diag_suppress=68
  c include: .\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Libraries\CMSIS\CM3\CoreSupport;.\User;.\User\lvgl;.\User\lvgl\src;.\User\lvgl\src\core;.\User\lvgl\src\draw;.\User\lvgl\src\extra;.\User\lvgl\src\font;.\User\lvgl\src\gpu;.\User\lvgl\src\hal;.\User\lvgl\src\misc;.\User\lvgl\src\widgets;.\User\lvgl\src\extra\layouts;.\User\lvgl\src\extra\libs;.\User\lvgl\src\extra\others;.\User\lvgl\src\extra\themes;.\User\lvgl\src\extra\widgets;.\User\lvgl\examples\porting;.\User\lvgl\demos\widgets;.\User\lvgl\demos
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group FW
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group User
    ./User/: main.c stm32f10x_it.c
    ./User/systick/: systick.c
    ./User/esp8266/: esp8266.c esp8266_app.c
    ./User/usart/: usart.c
  group StartUp
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group lcd
    ./User/lcd/: fonts.c ili9341_lcd.c xpt2046_lcd.c
  group GUI
    ./User/gui/: led_controller.c
  group lv_core
    ./User/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group lv_draw
    ./User/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ./User/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ./User/lvgl/src/draw/nxp_pxp/: lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ./User/lvgl/src/draw/nxp_vglite/: lv_gpu_nxp_vglite.c
    ./User/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ./User/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
  group lv_extra
    ./User/lvgl/src/extra/: lv_extra.c
    ./User/lvgl/src/extra/layouts/flex/: lv_flex.c
    ./User/lvgl/src/extra/layouts/grid/: lv_grid.c
    ./User/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ./User/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ./User/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ./User/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ./User/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ./User/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ./User/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ./User/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ./User/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ./User/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ./User/lvgl/src/extra/others/monkey/: lv_monkey.c
    ./User/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ./User/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ./User/lvgl/src/extra/themes/default/: lv_theme_default.c
    ./User/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ./User/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ./User/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ./User/lvgl/src/extra/widgets/chart/: lv_chart.c
    ./User/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ./User/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ./User/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ./User/lvgl/src/extra/widgets/led/: lv_led.c
    ./User/lvgl/src/extra/widgets/list/: lv_list.c
    ./User/lvgl/src/extra/widgets/menu/: lv_menu.c
    ./User/lvgl/src/extra/widgets/meter/: lv_meter.c
    ./User/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ./User/lvgl/src/extra/widgets/span/: lv_span.c
    ./User/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ./User/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ./User/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ./User/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ./User/lvgl/src/extra/widgets/win/: lv_win.c
  group lv_font
    ./User/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group lv_hal
    ./User/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lv_misc
    ./User/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lv_widgets
    ./User/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group lv_port
    ./User/lvgl/examples/porting/: lv_port_disp.c lv_port_indev.c
software components: Compiler:I/O:STDERR 1.2.0
